## boards/shields/alice60/Kconfig.defconfig
```kconfig
if SHIELD_ALICE60

config ZMK_KEYBOARD_NAME
    default "alice60"
	
# LED indicators
CONFIG_ZMK_HID_INDICATORS=y
CONFIG_LED=y

endif
```
